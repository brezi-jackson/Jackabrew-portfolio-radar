# Keil uVision project atk_f103.uvprojx, settings and files
target IIC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\User;..\..\Middlewares;..\..\Drivers\BSP\BEEP;..\..\Drivers\BSP\ADC;..\..\Drivers\BSP\CS1237;..\..\Drivers\BSP\DS18B20;..\..\Drivers\BSP\MOTOR;..\..\Drivers\BSP\OLED;..\..\Drivers\BSP\SCALE;..\..\Drivers\BSP\TIMER;..\..\Drivers\BSP\24CXX;..\..\Drivers\BSP\IIC;..\..\Drivers\BSP\LED;..\..\Drivers\BSP\LCD;..\..\Drivers\BSP\KEY;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\usart;..\..\Drivers\BSP\EXTI;..\..\Drivers\SYSTEM\usart;..\..\Middlewares\USMART;..\..\Drivers\BSP\PIC;..\..\Drivers\BSP\GUI;..\..\Drivers\BSP\SPI;..\..\Drivers\BSP\TEST;..\..\Drivers\BSP\CS1231;..\..\Drivers\BSP\INIT;..\..\Drivers\BSP\TIMER;..\..\Drivers\BSP\DMA;..\..\Drivers\BSP\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c task.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/MOTOR/: motor.c
    ../../Drivers/BSP/TIMER/: timer.c
    ../../Drivers/BSP/TEST/: test.c
    ../../Drivers/BSP/GUI/: GUI.c
    ../../Drivers/BSP/SPI/: SPI.c
    ../../Drivers/BSP/INIT/: Init.c
    ../../Drivers/BSP/OLED/: oled.c
    ../../Drivers/BSP/FLASH/: stmflash.c
  group Readme
    ../../: readme.txt
target SPI (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\User;..\..\Middlewares;..\..\Drivers\BSP\BEEP;..\..\Drivers\BSP\ADC;..\..\Drivers\BSP\CS1237;..\..\Drivers\BSP\DS18B20;..\..\Drivers\BSP\MOTOR;..\..\Drivers\BSP\OLED;..\..\Drivers\BSP\SCALE;..\..\Drivers\BSP\TIMER;..\..\Drivers\BSP\24CXX;..\..\Drivers\BSP\IIC;..\..\Drivers\BSP\LED;..\..\Drivers\BSP\LCD;..\..\Drivers\BSP\KEY;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\usart;..\..\Drivers\BSP\EXTI;..\..\Drivers\SYSTEM\usart;..\..\Middlewares\USMART;..\..\Drivers\BSP\PIC;..\..\Drivers\BSP\GUI;..\..\Drivers\BSP\SPI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
