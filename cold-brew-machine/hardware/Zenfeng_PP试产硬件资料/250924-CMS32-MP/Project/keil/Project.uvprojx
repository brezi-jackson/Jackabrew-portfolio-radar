# Keil uVision project Project.uvprojx, settings and files
target CMS32x506 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32M6526CGE24SS Cmsemicon
  pack: Cmsemicon.CMS32M65xx.0.6.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: M6510_0904 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\CMSIS\Include;..\..\Driver\inc;..\..\Device\Include;..\code\head;..\code\head\0_user_h;..\code\head\1_motlib_h;..\code\head\2_host_h
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user_flie
    ../code/source/0_user_s/: demo_ccp.c demo_epwm.c demo_adc.c demo_uart.c flash.c demo_pga.c
  group user_s
    ../code/source/0_user_s/: isr.c main.c hardinit.c mc_ctrl.c mc_foc.c interrupt.c softinit.c user_control.c
  group user_h
    ../code/head/0_user_h/: para_define.h
  group host_h
    ../code/head/2_host_h/: user_hostinithex.h
  group host_s
    ../code/source/2_host_s/: user_hostinithex.c
  group motlib_s
    ../code/source/1_motlib_s/: CMS_65_FOCA_V220.lib
  group driver_h
    ../../Driver/inc/: acmp.h adc.h ccp.h cgc.h common.h crc.h divsqrt.h epwm.h fmc.h gpio.h i2c.h opa.h pga.h ssp.h system.h timer.h uart.h wdt.h wwdt.h
  group driver_s
    ../../Driver/src/: acmp.c adc.c ccp.c epwm.c gpio.c pga.c timer.c uart.c cgc.c divsqrt.c wdt.c dac.c adcldo.c
  group device_s
    ../../Device/Source/: system_CMS32M6510.c
    ../../Device/Source/ARM/: startup_CMS32M6510.s
  group doc
    ../code/source/: record.txt
